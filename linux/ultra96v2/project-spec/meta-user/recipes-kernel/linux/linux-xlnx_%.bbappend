SRC_URI += "file://bsp.cfg \
            file://user_2019-07-29-23-56-00.cfg \
            file://user_2019-09-02-15-56-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
